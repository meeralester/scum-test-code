# Keil uVision project code.uvprojx, settings and files
target SCM_3C (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: code
  AfterMake: fromelf --bin code.axf -o code.bin
  AfterMake: fromelf -cvf code.axf -o disasm.txt
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Baseline
    ./: main.c cm0dsasm.s Int_Handlers.h Memory_Map.h retarget.c
    ./: scm3C_hardware_interface.c scm3C_hardware_interface.h scm3_hardware_interface.c scm3_hardware_interface.h
  group Sensor_ADC
    ./sensor_adc/: adc_config.h adc_config.c adc_test.h adc_test.c
  group Radio
    ./: rf_global_vars.h
    ./: scum_radio_bsp.h scum_radio_bsp.c
  group Testbench
    ./: test_code.c test_code.h
